# Keil uVision project scvn.uvproj, settings and files
target test (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F2XX, TNKERNEL_PORT_CORTEXM3
  c include: .\TNKernel\CortexM3;.\TNKernel\;.\user;.\StdLib\CMSIS\CoreSupport;.\StdLib\CMSIS\STM32F2xx;.\StdLib\STM32F2xx_StdPeriph_Driver\inc;.\bspStdLib\inc;.\..\..\wigets\inc;.\..\..\GUICore\inc;.\..\..\driver\inc;.\..\..\utils\inc;.\appGUI
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group TNKernel
    ./TNKernel/: tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_sem.c tn_tasks.c tn_utils.c
    ./TNKernel/CortexM3/: tn_port_cm3.c tn_port_cm3_armcc.s
  group StdLib
    ./StdLib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_rtc.c stm32f2xx_adc.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_spi.c
  group CMSYS
    ./StdLib/CMSIS/CoreSupport/: core_cm3.c
    ./StdLib/CMSIS/STM32F2xx/: system_stm32f2xx.c
    ./StdLib/CMSIS/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group GUI
    ./../../driver/src/: lcdHAL_universal.c lcdHAL_ILI9320.c lcdHAL_HX8347A.c ee_emul.c beeper.c mkDriver_207Z.c ads7843_207Z.c
    ./../../GUICore/src/: guiColor.c guiPrimitives.c guiText.c widget.c guiFontsMin.c
    ./../../utils/src/: afTime.c
    ./../../wigets/src/: guiChart.c guiCheckBox.c guiLabel.c guiRadioGroup.c guiTextButton.c guiTouchCalibration.c guiUpDownBox.c
  group user
    ./user/: startup_hardware_init.s main.c tn_user.c hw_init.c
  group bspStdLib
    ./bspStdLib/src/: crcm.c button.c at26df.c uartdrv.c tn_task_usart.c
  group appGUI
    ./appGUI/: appGui.c HMI_Control.c winMain.c winUartCfg.c winPlot.c
